v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 0 -10 0 20 {
lab=#net3}
N 0 80 0 110 {
lab=GND}
C {isource.sym} 0 50 0 0 {name=I0 value=1m}
C {gnd.sym} 10 110 0 0 {name=l1 lab=GND}
